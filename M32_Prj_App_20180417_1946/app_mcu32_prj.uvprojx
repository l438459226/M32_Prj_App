# Keil uVision project app_mcu32_prj.uvprojx, settings and files
target ExtMCU32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M32_Control +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, HSE_VALUE=16000000L
  c include: .\Src\STM32F1xx_Std_Driver\Include;.\Src\STM32F1xx_Std_Driver\StdPeriph_Driver\inc;.\Src\STM32F1xx_Std_Driver\CMSIS\4.2.0\Include;.\Src;.\Src\LCD240X320;.\Src\power
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group START_UP
    ./Src/STM32F1xx_Std_Driver/Source/: system_stm32f10x.c
    ./Src/STM32F1xx_Std_Driver/Source/ARM/: startup_stm32f10x_hd.s
  group STD_DRIVER
    ./Src/STM32F1xx_Std_Driver/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_spi.c
  group APP
    ./Src/: main.c user_gpio_def.c app.c pport_spi.c timer.c tools.c user_config.c
  group DebugPrint
    ./Src/: redef_print.c DBG_uart.c
  group LCD
    ./Src/LCD/: lcd_cfg_1080x1920_TianJi2.c lcd_cfg_1080x1920_OppoR9_Oled.c
  group Power
    ./Src/: power_task.c
    ./Src/power/: vspn_ctrl.c i2c.c
  group LCD240x320
    ./Src/LCD240X320/: font.c font_Hanzi.c LogoArray.c lcd240x320.c
  group MCU_GPU
    ./Src/: MCU_GPU_fsmc.c GPU_Cfg.c ExternalIntWithGPU.c GPU_Cfg_Pattern.c sd.c gpu_pll_reconfig.lib GpuSpiFlsCfg_AndBoardInf.lib
    ./Src/FileSys/: Fat32Sys_ForFastFIFORead.c
